options:
  parameters:
    generate_options: qt_gui
    id: radio_one
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_dial_control
  parameters:
    label: Gain
    maximum: '3'
    minimum: '0'
    minsize: '0'
    scaleFactor: '0.25'
    showvalue: 'True'
    type: real
    value: '0.5'
  states: {state: disabled}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.25'
    stop: '4'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: 102.8e6
  states: {state: disabled}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 87.5e6
    step: '1'
    stop: 108e6
    value: 102.8e6
  states: {}
- name: channel_freq_2
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 87.5e6
    step: '1'
    stop: 108e6
    value: 102.8e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"plot 1"'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    name: '"plot 2"'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
